Commit message: changes box delivery

File: aliengo_gazebo/launch/world/my_box.urdf (robot description, URDF)
Before this commit: robot simple_box, 1 links, 0 joints
Links:
- link my_box: mass 5.0 -> 1.0
